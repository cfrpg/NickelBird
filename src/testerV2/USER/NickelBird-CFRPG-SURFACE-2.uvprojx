# Keil uVision project NickelBird-CFRPG-SURFACE-2.uvprojx, settings and files
target NickelBird (5060750::V5.06 update 6 (build 750)::.\ARM_Compiler_5.06u6)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NickelBird +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_HS,USE_EMBEDDED_PHY
  c include: ..\CORE;..\USER;..\STM32F4\inc;..\MODULE;..\HARDWARE;..\SYSTEM;..\PAGES;..\SYSTEM\USB\Core\inc;..\SYSTEM\USB\Core\src;..\SYSTEM\USB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group STM32F4
    ../STM32F4/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group HARDWARE
    ../HARDWARE/: led.c parameter.c pwm.c sblink.c sblinkutility.c timer.c ad7606fsmc.c ad7606fsmc.h extin.c extin.h sensors.h sensors.c oled.c oled.h font.h keyboard.c keyboard.h mb85rs.c mb85rs.h parameterList.c sampling.c sampling.h
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c nickelbird.h
  group MODULE
    ../MODULE/: MathHelper.c MathHelper.h pid.c pid.h filter.c filter.h
  group PAGES
    ../PAGES/: pages.h logo.h pages.c MainPage.c FalconPage.c ControllerPage.c
